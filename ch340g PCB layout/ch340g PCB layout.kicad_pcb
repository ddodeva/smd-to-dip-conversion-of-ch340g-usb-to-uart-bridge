# Repository ddodeva/smd-to-dip-conversion-of-ch340g-usb-to-uart-bridge

File README.md:

# smd-to-dip-conversion-of-ch340g-usb-to-uart-bridge
this gerber files will help you convert you ch340g usb to uart smd chip to dip chip

## KiCad design ch340g PCB layout/ch340g PCB layout.kicad_pcb

Parts:
J1, J2: Conn_01x08_Male; Pin_Header_Straight_1x08_Pitch1.27mm
U1: CH340G; SO-16-N

Connections:
/CTS: J2.1, U1.9 (CTS)
/D+: J1.5, U1.5 (D+)
/D-: J1.6, U1.6 (D-)
/DCD: J2.4, U1.12 (DCD)
/DSR: J2.2, U1.10 (DSR)
/DTR: J2.5, U1.13 (DTR)
/RI: J2.3, U1.11 (RI)
/RS232: J2.7, U1.15 (RS232)
/RTS: J2.6, U1.14 (RTS)
/RX: J1.3, U1.3 (RX)
/TX: J1.2, U1.2 (TX)
/V3: J1.4, U1.4 (V3)
/VCC: J2.8, U1.16 (VCC)
/X0: J1.8, U1.8 (XO)
/X1: J1.7, U1.7 (XI)
/gnd: J1.1, U1.1 (GND)

Board: 2 copper layers, 25.4 x 16.5 mm, 3 parts (0 on the bottom side), 16 nets.

## Commit log

2020-11-09 Add files via upload
    and i have also added the ch340g chip ki cad library file , with which you could add the .lib file to your ki cad library , to get the schematic of ch340g
